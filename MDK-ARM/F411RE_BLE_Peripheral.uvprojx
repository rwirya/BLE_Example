# Keil uVision project F411RE_BLE_Peripheral.uvprojx, settings and files
target F411RE_BLE_Peripheral (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F411RE_BLE_Peripheral +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../BlueNRG-2/Target;      ../Core/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc;      ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;      ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;      ../Drivers/CMSIS/Include;      ../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic;      ../Middlewares/ST/BlueNRG-2/utils;      ../Middlewares/ST/BlueNRG-2/includes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: BLE_Process.c main.c custom_bus.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/User/BlueNRG-2/Target
    ../BlueNRG-2/Target/: hci_tl_interface.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/HCI_TL/Basic
    ../Middlewares/ST/BlueNRG-2/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../Middlewares/ST/BlueNRG-2/hci/: bluenrg1_devConfig.c bluenrg1_events.c bluenrg1_events_cb.c bluenrg1_hci_le.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Utils
    ../Middlewares/ST/BlueNRG-2/utils/: ble_list.c
  group Middlewares/BlueNRG-2/Wireless/BlueNRG-2/Controller
    ../Middlewares/ST/BlueNRG-2/hci/controller/: bluenrg1_gap_aci.c bluenrg1_gatt_aci.c bluenrg1_hal_aci.c bluenrg1_l2cap_aci.c
software components: CMSIS:CORE 5.4.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
